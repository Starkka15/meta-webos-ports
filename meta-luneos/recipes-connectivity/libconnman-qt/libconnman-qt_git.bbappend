SRC_URI:append = " file://0001-libconnman-qt.pro-Disable-hidden-visibility-for-Qt6.patch"
