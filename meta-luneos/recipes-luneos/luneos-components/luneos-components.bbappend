SRC_URI:append = " file://0001-shell.pro-Disable-hidden-visibility-for-Qt6-plugin.patch"
